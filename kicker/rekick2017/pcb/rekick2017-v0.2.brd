# Repository carpe-noctem-cassel/cnc-circuit-boards (continued)

## EAGLE design powerSwitch/pcb/CNC-PowerSwitch-2016-v0.92.brd (continued)

Parts:
5V, 12V: LEDCHIPLED_0805; CHIPLED_0805
C1, C24: 100n/10V; C0603
GELB: LEDCHIPLED_0805; CHIPLED_0805
GRÜN: LEDCHIPLED_0805; CHIPLED_0805
H5, H6, H7, H8: MOUNT-PAD-ROUND3.0; 3,0-PAD
KICK: LEDCHIPLED_0805; CHIPLED_0805
LED_BLAU: LEDCHIPLED_0805; CHIPLED_0805
R1, R7: 50k; R0805
R4: 120; R0805
R5: 4k7; R0805
R6: 120; M0805
R15, R16, R17, R23: 100k; R0805
R18, R25, R26, R27, R29: 150; R0805
R28: 560; R0805
R31: 1k; R0805
RJ_1, RJ_2: RJ10
ROT: LEDCHIPLED_0805; CHIPLED_0805
R_NULL_1, R_NULL_2, R_NULL_3, R_NULL_4: 0; R0402
SJ1, SJ2: SJ
T1, T2, T3, T5, T6, T7: BC849; SOT23
T4: BC859; SOT23-BEC
TDB-05: F/CM12P
U$1: MCP2551-I/SN; SOIC127P600X175-8N

Connections:
12V: R16.1, R_NULL_3.1; also elsewhere on the board
12V-AKKU: R28.1; also elsewhere on the board
12V-EXT: R1.1; also elsewhere on the board
+5V: C1.2, C24.2, R4.1, R18.2, R25.1, R26.1, R27.1, R29.1, SJ2.1, T4.E, TDB-05.+ (1), U$1.3 (VDD); also elsewhere on the board
AKTUATOR: R17.1, R_NULL_2.1; also elsewhere on the board
CANH: R6.1, RJ_1.P$2, RJ_2.P$2, U$1.7 (CANH)
CANL: RJ_1.P$3, RJ_2.P$3, SJ1.1, U$1.6 (CANL)
GND: 5V.C, 12V.C, C1.1, C24.1, H5.B3,0, H6.B3,0, H7.B3,0, H8.B3,0, R31.1, RJ_1.P$1, RJ_2.P$1, T1.2 (E), T2.2 (E), T3.2 (E), T5.2 (E), T6.2 (E), T7.2 (E), U$1.2 (VSS); also elsewhere on the board
ICLED_AKT: GELB.C, T6.3 (C); also elsewhere on the board
ICLED_GRUEN: GRÜN.C, T7.3 (C); also elsewhere on the board
ICLED_KICK: KICK.C, T2.3 (C); also elsewhere on the board
ICLED_ROT: ROT.C, T5.3 (C); also elsewhere on the board
KICKER: R23.1, R_NULL_1.1; also elsewhere on the board
LED_BLAU: T4.C; also elsewhere on the board
LED_GELB: R_NULL_2.2; also elsewhere on the board
LED_GRUEN: R_NULL_4.2; also elsewhere on the board
LED_KICK: R_NULL_1.2; also elsewhere on the board
LED_ROT: R_NULL_3.2; also elsewhere on the board
MOTION: R15.1, R_NULL_4.1; also elsewhere on the board
unnamed: R5.2, T1.1 (B)
unnamed: RJ_1.P$4, RJ_2.P$4, SJ2.2
unnamed: R23.2, T2.1 (B)
unnamed: KICK.A, R29.2
unnamed: R31.2, U$1.8 (RS)
unnamed: R6.2, SJ1.2
unnamed: GELB.A, R25.2
unnamed: R26.2, ROT.A
unnamed: R1.2, T3.1 (B)
unnamed: LED_BLAU.A, R4.2
unnamed: LED_BLAU.C, R7.1, T3.3 (C)
unnamed: R7.2, T4.B
unnamed: T1.3 (C), TDB-05.- (2)
unnamed: GRÜN.A, R27.2
unnamed: 12V.A, R28.2
unnamed: R16.2, T5.1 (B)
unnamed: R17.2, T6.1 (B)
unnamed: R15.2, T7.1 (B)
unnamed: 5V.A, R18.1
RXCAN: U$1.4 (RXD); also elsewhere on the board
SPEAKER: R5.1; also elsewhere on the board
TXCAN: U$1.1 (TXD); also elsewhere on the board

Notes on the sheet:
CAN
Speaker
Massepads
Leds

Parts:
C6: 100n/10V; C0603
D1, D3: ES1A; SMA-DO214AC
D4: Z 3.3V; SOT23
IC1: LM1458D; SO08
IC4: BTS555; TO220-51
IC11, IC12: BTS6133; TO252-51
OK1: ILD213; SOIC08
Q2, Q3, Q4, Q5: IRF9530; TO220BV
R13, R22: 100k; R0805
R14, R19, R20, R21, R32: 1k; R0805
R24: 560; R0805
R30, R36, R38, R40: 100k 0.1%; R0805
R34, R42: 10k; R0805
R35, R46: 240k 0.1%; R0805
R37, R39, R41: 560k 0.1%; R0805
R45: 910k 0.1%; R0805
VR1, VR2, VR3, VR7, VR8, VR9: TL431_SOT23; SOT23

Connections:
12V: Q3.D, Q5.D; also elsewhere on the board
12V-AKKU: D3.A, Q4.D, R35.2, R42.1; also elsewhere on the board
12V-EXT: D1.A, Q2.D, R34.1, R45.2; also elsewhere on the board
12V-I-OPV: IC1.3 (+IN); also elsewhere on the board
24VIN: IC4.3 (VBB), IC11.TAB (VBB), IC12.TAB (VBB), R37.2, R39.2, R41.2; also elsewhere on the board
+5V: C6.1, IC1.8 (V+), R24.1; also elsewhere on the board
ADC2/I-AKT: IC11.IS, R19.2; also elsewhere on the board
ADC3/I-12V: IC1.1 (OUT), R13.2; also elsewhere on the board
ADC5/I-KICK: IC12.IS, R14.2; also elsewhere on the board
ADC6/I-MOT: IC4.4 (IS), R20.2; also elsewhere on the board
AKTUATOR: IC11.OUT1 (OUT), IC11.OUT2 (OUT); also elsewhere on the board
DIV-AKKU: R30.2, R35.1, VR2.1 (C), VR3.2 (R)
DIV-EXT: R45.1, R46.2, VR1.2 (R), VR2.2 (R)
GND: C6.2, D4.1 (A), IC1.4 (V-), R14.1, R19.1, R20.1, R21.1, R30.1, R36.1, R38.1, R40.1, R46.1, VR1.3 (A), VR2.3 (A), VR3.3 (A); also elsewhere on the board
KICKER: IC12.OUT1 (OUT), IC12.OUT2 (OUT); also elsewhere on the board
MOTION: IC4.1 (OUT1), IC4.5 (OUT2); also elsewhere on the board
unnamed: OK1.1 (A), R32.1
unnamed: OK1.7 (EMIT), VR1.1 (C)
unnamed: OK1.2 (C), OK1.3 (A)
unnamed: IC1.2 (-IN), R13.1, R21.2, R22.1
unnamed: D4.3 (C), R22.2, R24.2
unnamed: Q2.S, Q3.S
unnamed: OK1.6 (COL), Q4.G, Q5.G, R42.2
unnamed: Q4.S, Q5.S
unnamed: OK1.5 (EMIT), VR3.1 (C)
unnamed: D1.K (C), D3.K (C), R32.2
unnamed: IC12.IN, VR8.1 (C)
unnamed: IC4.2 (IN), VR9.1 (C)
unnamed: IC11.IN, VR7.1 (C)
unnamed: R36.2, R37.1, VR7.2 (R)
unnamed: R38.2, R39.1, VR8.2 (R)
unnamed: R40.2, R41.1, VR9.2 (R)
unnamed: OK1.8 (COL), Q2.G, Q3.G, R34.2
SW_12V: OK1.4 (C); also elsewhere on the board
SW_AKT: VR7.3 (A); also elsewhere on the board
SW_KICK: VR8.3 (A); also elsewhere on the board
SW_MOT: VR9.3 (A); also elsewhere on the board

Notes on the sheet:
Intern
Extern
Supply
Motion
Kicker
Actuator

Board: 2 copper layers, 53.3 x 99.7 mm, 114 parts (60 on the bottom side), 84 nets.

## EAGLE design actuator/BBB_Cape/pcb/CN-Cape-1.1.brd

Board: 2 copper layers, 160.0 x 86.4 mm, 108 parts (59 on the bottom side), 101 nets.

Parts:
5V1, 5V2, 5V3, 24V: CHIP-LED0603
ADC1, ADC2, ADC3: 1X03
BALL-HANDLE_LEFT: 1X08
BALL-HANDLE_RIGHT: 1X08
C1, C2, C3, C7, C8, C9, C10, C11, C13, C14, C16, C17: 100nF; C0603
C4, C6: 220µF; E2,5-6
C5, C18: 220µF; E3,5-8
C19, C20: 470µF; E3,5-8
CAN: RJ10
CON_IMU: 1X09
CON_IMU2: 1X05
CON_SPI-EXT: ML6
CON_STECKERBOX: ML10
D4, D8, D9: SOD123
D5: BY550; DO27-15
D6: MBRS140; SMB
D7: MBRS360; SMC
H1, H2, H3, H4: MOUNT-PAD-ROUND3.0; 3,0-PAD
I2C: 1X02
IC3: LM340MP-05; SOT223
IC4: LM2576; TO220-5_STAGGERED
IC5: LM2575; TO220-5_STAGGERED
JP3, JP4: 1X02
JST_CHASSIS: S7PIN; S7B-EH
JST_OPTICAL-FLOW: S8PIN; S8B-EH
L1: 330µH; PISR
L2: 100µH; PISR
LS_SPI: TXB0108PWR; SOP65P640X120-20N
NPN1, NPN2, NPN3, NPN4: BC849SMD; SOT23-BEC
P8, P9: BeagleBoard 2x23; 2X23
PNP1, PNP2, PNP3, PNP4: BC858BSMD; SOT23-BEC
R1, R19, R20, R21, R22: 1k; R0805
R2, R6, R7, R8: 120; R0805
R3, R4, R10, R11, R12, R13, R14, R15, R16, R17, R18, R27, R28, R31, R32, R33, R34, R35: 10k; R0805
R5: 1200; R0805
R9: ADJ; R0805
R23, R24, R25, R26: 1,8k; R0805
R29, R30: 330; R0805
SERVO1, SERVO2: 1X03
SJ1, SJ2: SJ
U1, U3: ADUM1200ARZ; SOIC127P600X175-8N
U2, U4: ADUM1300ARWZ; SOIC127P1032X265-16N
U$1: MCP2551-I/SN; SOIC127P600X175-8N
X2: AK500/2-H

Connections:
!BH_L_RESET: BALL-HANDLE_LEFT.4, U4.12
!BH_L_RESET_3V: P8.8, U4.5
!BH_R_RESET: BALL-HANDLE_RIGHT.4, U2.12
!BH_R_RESET_3V: P8.10, U2.5
+3V3: C7.1, C9.1, C13.2, CON_IMU.1, LS_SPI.2, LS_SPI.10, P9.3, P9.4, R27.2, R28.2, U1.8, U3.8
+5V/1: ADC1.1, ADC2.1, ADC3.1, C1.1, C2.1, C4.+, C6.+, C8.1, C14.2, CON_SPI-EXT.2, IC5.FB, JST_CHASSIS.7, JST_OPTICAL-FLOW.8, L1.P$2, LS_SPI.19, P9.5, P9.6, PNP1.E, PNP2.E, PNP3.E, PNP4.E, R4.2, R6.2, R13.2, R14.2, R15.2, U$1.3
+5V/2: C3.1, C11.1, C19.+, C20.+, IC4.FB, JP3.1, JP4.1, L2.P$2, R7.2, SERVO1.2, SERVO2.2, SJ1.2, U2.1, U4.1
+5V/3: C10.1, C17.1, D4.A, IC3.3, R8.2, U1.1, U2.16, U3.1, U4.16
+24V: C5.+, C18.+, D5.C, IC4.IN, IC5.IN, R5.2
+24V/3: C16.1, D4.C, D8.C, D9.C, IC3.1
ADC0_1.8V: P9.39, R19.2, R23.1
ADC1: ADC1.3, R24.2
ADC1_1.8V: P9.40, R20.2, R24.1
ADC2: ADC2.3, R25.2
ADC2_1.8V: P9.37, R21.2, R25.1
ADC3: ADC3.3, R26.2
ADC3_1.8V: P9.38, R22.2, R26.1
BH_L_DIR: BALL-HANDLE_LEFT.2, U4.14
BH_L_DIR_3V: P8.7, U4.3
BH_L_FF1: BALL-HANDLE_LEFT.5, U3.3
BH_L_FF1_3V: P8.12, U3.6
BH_L_FF2: BALL-HANDLE_LEFT.6, U3.2
BH_L_FF2_3V: P8.14, U3.7
BH_L_PWM: BALL-HANDLE_LEFT.3, U4.13
BH_L_PWM_3V: P8.13, U4.4
BH_R_DIR: BALL-HANDLE_RIGHT.2, U2.14
BH_R_DIR_3V: P8.9, U2.3
BH_R_FF1: BALL-HANDLE_RIGHT.5, U1.3
BH_R_FF1_3V: P8.16, U1.6
BH_R_FF2: BALL-HANDLE_RIGHT.6, U1.2
BH_R_FF2_3V: P8.18, U1.7
BH_R_PWM: BALL-HANDLE_RIGHT.3, U2.13
BH_R_PWM_3V: P8.19, U2.4
CANH: CAN.P$3, SJ2.2, U$1.7
CANL: CAN.P$2, R2.2, U$1.6
CAN_RX: LS_SPI.12, U$1.4
CAN_RX_3V: LS_SPI.9, P9.24
CAN_TX: LS_SPI.13, U$1.1
CAN_TX_3V: LS_SPI.8, P9.26
DRDY: CON_IMU2.3, P8.15
GND: 5V1.C, 5V2.C, 24V.C, ADC1.2, ADC2.2, ADC3.2, C1.2, C2.2, C3.2, C4.-, C5.-, C6.-, C7.2, C8.2, C9.2, C11.2, C13.1, C14.1, C18.-, C19.-, C20.-, CAN.P$4, CON_IMU.3, CON_SPI-EXT.6, CON_STECKERBOX.1, CON_STECKERBOX.2, D6.A, D7.A, H1.B3,0, H2.B3,0, H3.B3,0, H4.B3,0, IC4.!EN, IC4.GND, IC5.!EN, IC5.GND, JP3.2, JP4.2, JST_CHASSIS.1, JST_CHASSIS.3, JST_CHASSIS.5, JST_OPTICAL-FLOW.1, LS_SPI.11, NPN1.E, NPN2.E, NPN3.E, NPN4.E, P8.1, P8.2, P9.1, P9.2, P9.34, P9.43, P9.44, P9.45, P9.46, R1.1, R3.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, SERVO1.1, SERVO2.1, U1.5, U2.2, U2.8, U3.5, U4.2, U4.8, U$1.2, X2.2
GND3: 5V3.C, BALL-HANDLE_LEFT.1, BALL-HANDLE_RIGHT.1, C10.2, C16.2, C17.2, IC3.4, U1.4, U2.9, U2.15, U3.4, U4.9, U4.15
I2C2_SCL: CON_IMU.4, P9.19, R27.1, R29.1
I2C2_SDA: CON_IMU.5, P9.20, R28.1, R30.1
INT1: CON_IMU2.4, P8.17
INT2: CON_IMU2.5, P8.26
INTG: CON_IMU2.2, P8.11
LB_ADC: JST_CHASSIS.4, R23.2
unnamed: NPN1.C, R10.2, R13.1
unnamed: NPN2.C, R11.2, R14.1
unnamed: NPN4.C, R4.1, R31.2
unnamed: NPN3.C, R12.2, R15.1
unnamed: D5.A, X2.1
unnamed: 24V.A, R5.1
unnamed: 5V1.A, R6.1
unnamed: 5V2.A, R7.1
unnamed: R1.2, U$1.8
unnamed: R2.1, SJ2.1
unnamed: D6.C, IC5.OUT, L1.P$1
unnamed: D7.C, IC4.OUT, L2.P$1
unnamed: BALL-HANDLE_LEFT.8, D9.A
unnamed: BALL-HANDLE_RIGHT.8, D8.A
unnamed: 5V3.A, R8.1
unnamed: JST_CHASSIS.6, R9.2
unnamed: I2C.1, R29.2
unnamed: I2C.2, R30.2
unnamed: CAN.P$1, SJ1.1
unnamed: PNP1.B, R10.1
unnamed: PNP2.B, R11.1
unnamed: PNP3.B, R12.1
unnamed: PNP4.B, R31.1
unnamed: NPN1.B, R32.1
unnamed: NPN2.B, R33.1
unnamed: NPN3.B, R34.1
unnamed: NPN4.B, R35.1
OF_LED: PNP4.C, R9.1
OF_LED_3V: P9.12, R3.2, R35.2
OF_NCS_3V: JST_OPTICAL-FLOW.3, P9.30
OF_NPD_3V: JST_OPTICAL-FLOW.5, P9.25
OF_RST_3V: JST_OPTICAL-FLOW.7, P9.27
SERVO_PWM: LS_SPI.14, SERVO1.3
SERVO_PWM2: LS_SPI.15, SERVO2.3
SERVO_PWM2_3V: LS_SPI.6, P9.16
SERVO_PWM_3V: LS_SPI.7, P9.14
SPI0_CLK: JST_OPTICAL-FLOW.6, LS_SPI.5, P9.22
SPI0_CS: LS_SPI.1, P9.17
SPI0_D0_MISO: JST_OPTICAL-FLOW.4, LS_SPI.4, P9.21
SPI0_D1_MOSI: JST_OPTICAL-FLOW.2, LS_SPI.3, P9.18
SPI_CLK: CON_SPI-EXT.3, LS_SPI.16
SPI_CS: CON_SPI-EXT.5, LS_SPI.20
SPI_MISO: CON_SPI-EXT.1, LS_SPI.17
SPI_MOSI: CON_SPI-EXT.4, LS_SPI.18
SW_BUNDLE-LED: CON_STECKERBOX.8, PNP2.C
SW_BUNDLE-LED_3V: P9.41, R17.2, R33.2
SW_BUNDLE_3V: CON_STECKERBOX.7, P9.13
SW_POWER-LED: CON_STECKERBOX.10, PNP3.C
SW_POWER-LED_3V: P9.23, R16.2, R34.2
SW_PWR_BUT: CON_STECKERBOX.9, P9.9
SW_VISION-LED: CON_STECKERBOX.6, PNP1.C
SW_VISION-LED_3V: P9.42, R18.2, R32.2
SW_VISION_3V: CON_STECKERBOX.5, P9.11

## Code that names these connections

File kicker/rekick2017/src/defaults.h:

#ifndef	DEFAULTS_H
#define	DEFAULTS_H

#define	MISO			B,0
#define	MOSI			B,1
#define	SCK				B,7

// Boost and Kick
#define KICK			C,7
#define RESET_NOTAUS	B,4
#define NOTAUS			B,5
#define TRIGGER_NOTAUS	B,6

// Control Boost Controller
#define FAULT			C,4
#define CHARGE			C,6
#define DONE			B,3		// Is not implemented. Change R_BG from 0 to a value you calculate -> datasheet(LT3751)

// Control Active States
#define ACTIVATE_BOOSTER	C,5
#define ACTIVATE_SERVO		D,7
#define SERVO_PWM			C,1

// ADC Pins
#define PIN_24V_LOGIC		D,4
#define PIN_24V_BOOSTER		D,5
#define PIN_CAP				D,6

// Ethernet Communication
#define INT_ETH			C,0
#define CS_ETH			D,0
#define RST_ETH			D,1

//#define ADC_24V_LOGIC		0x01	// ADC1 / D,4
//#define ADC_24V_BOOSTER		0x02	// ADC2 / D,5
//#define ADC_CAP				0x03	// ADC3 / D,6

// CAN and PWM
#define CAN_TX			C,2
#define CAN_RX			C,3
#define OC1A			D,2
#define OC0A			D,3

#endif	// DEFAULTS_H

## Commit log

2016-11-18 moved from msl_electronic_boards to new repository
2016-11-18 PowerSwitch PartList
2016-11-23 powerswitch
2016-11-24 powerswitch final version and partlist
2016-12-05 PowerSwitch with Ethernet
2016-12-06 powerswitch added ethernet, next step design
2016-12-14 powerswitch layout
2016-12-15 PowerSwitch Layout near finish
2016-12-28 PowerSwitch Layout finished
2016-12-29 start beagle2can board
2016-12-30 beagle2can layout finished
2017-01-12 little changes and part list for beagle2can, cape1.1
2017-01-27 cut-off for ethernet
2017-02-09 small fixes powerswitch
2017-10-25 kicker new version
2017-12-16 Kicker - Layout halb fertig
2017-12-20 Kicker 2017
2018-01-10 rekick2017 final version?
2018-01-31 kicker2017final
2018-03-05 adding kicker BOM
2018-03-17 Code for rekick2017 - needs testing
2018-03-21 new kicker files
2018-03-23 new files
2018-03-23 new kicker 2017 files
2018-03-27 new BOM and board files
2018-03-28 latest kicker files Please enter the commit message for your changes. Lines starting
2018-03-28 modified parameter for kick voltage calculation
2018-03-28 changed booster_ctrl() - activation/hold
2018-03-28 corrected fb-loop
2018-03-29 kicker 2017 v0.2 final
2018-03-29 new files rekick 2017
2018-04-11 rekick2017 0.2 (TODO: finish layout)

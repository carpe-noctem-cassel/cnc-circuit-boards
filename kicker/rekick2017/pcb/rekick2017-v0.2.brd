File: kicker/rekick2017/pcb/rekick2017-v0.2.brd (EAGLE design)
At the start: 160 x 100 mm, 184 parts, among them IC1 SN74LVC1G02DBVR, IC2 4043D, IC3 LM1117, IC4 MCP602-I/SN, P1 39-30-06?_S, P2 39-30-08?_S, Q1 16MHz, Q2 IKW40N120T2FKSA1, Q3 PSMN7R8-120PS, Q4 PSMN7R8-120PS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

Commit message: corrected fb-loop
Parts:
- removed R21: 180k, rcl:R0805
- removed R25: 56k, rcl:R0805
- removed R26: 4.7k, rcl:R0805
- added C20: 100n, rcl:C0603
- added R3: 4.7k, rcl:R0805
- added R35: 100k, rcl:R0805
Connections:
- removed net FB_OV: IC4.3, R21.1, R25.2
- removed net N$34: R25.1, R26.2
- new net FB_TRIG_LVL: C20.1, IC4.2, R3.1, R35.2
- net +5V/3: now also R3.2
- net ADC_CAP: now also IC4.3; no longer R21.2
- net GND: now also C20.2, R35.1; no longer R26.1
- net N$3: no longer IC4.2
Routing:
- net FB_OV: track 13.1 -> 0.00 mm
- net ADC_CAP: track 38.0 -> 32.5 mm
- net N$34: track 2.03 -> 0.00 mm
- net N$3: track 21.5 -> 20.3 mm
Changed lines of the file:
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@@
 <element name="R8" library="rcl" package="R0805" value="5,6k" x="23.876" y="33.274" rot="MR0"/>
 <element name="C37" library="rcl" package="C0603" value="1µ/16V" x="79.375" y="49.276" rot="R90"/>
-<element name="R21" library="rcl" package="R0805" value="180k" x="83.185" y="49.276" rot="MR90"/>
-<element name="R25" library="rcl" package="R0805" value="56k" x="85.217" y="49.276" rot="MR270"/>
-<element name="R26" library="rcl" package="R0805" value="4.7k" x="87.249" y="49.276" rot="MR90"/>
 <element name="R29" library="rcl" package="R0805" value="5,6k" x="72.644" y="61.468"/>
 <element name="D4" library="diode" package="SMA-DO214AC" value="ES1A" x="72.644" y="63.754" rot="R180"/>
@@
 <element name="R38" library="rcl" package="R1210" value="" x="120.65" y="44.704" rot="MR0"/>
 <element name="R39" library="rcl" package="R1210" value="" x="120.65" y="41.656" rot="MR0"/>
+<element name="R3" library="rcl" package="R0805" value="4.7k" x="-22.733" y="-27.813"/>
+<element name="R35" library="rcl" package="R0805" value="100k" x="-22.733" y="-33.909"/>
+<element name="C20" library="rcl" package="C0603" value="100n" x="-21.971" y="-39.37"/>
 </elements>
 <signals>
@@
 <contactref element="C15" pad="2"/>
 <contactref element="C46" pad="2"/>
-<contactref element="D8" pad="A"/>
 <contactref element="IC1" pad="3"/>
 <contactref element="IC2" pad="8"/>
@@
 <contactref element="C45" pad="2"/>
 <contactref element="C49" pad="2"/>
-<contactref element="C57" pad="2"/>
 <contactref element="C59" pad="1"/>
 <contactref element="C58" pad="1"/>
 <contactref element="H1" pad="B3,0"/>
 <contactref element="C37" pad="2"/>
-<contactref element="R26" pad="1"/>
 <contactref element="P1" pad="6"/>
 <contactref element="C23" pad="2"/>
@@
 <via x="91.567" y="19.05" extent="1-16" drill="0.5"/>
 <contactref element="RJ_1" pad="P$1"/>
+<contactref element="R35" pad="1"/>
+<contactref element="C20" pad="2"/>
+<contactref element="D8" pad="A"/>
+<contactref element="C57" pad="2"/>
 <wire x1="97.028" y1="62.357" x2="100.457" y2="62.487" width="0" layer="19" extent="16-16"/>
 <wire x1="93.345" y1="63.7032" x2="97.028" y2="62.357" width="0" layer="19" extent="1-1"/>
@@
 <wire x1="86.233" y1="53.086" x2="88.519" y2="55.792" width="0" layer="19" extent="16-16"/>
 <wire x1="85.201" y1="50.276" x2="86.233" y2="53.086" width="0" layer="19" extent="1-1"/>
-<wire x1="87.249" y1="48.326" x2="85.201" y2="50.276" width="0" layer="19" extent="1-16"/>
-<wire x1="89.662" y1="46.676" x2="87.249" y2="48.326" width="0" layer="19" extent="16-16"/>
-<wire x1="86.106" y1="45.466" x2="87.249" y2="48.326" width="0" layer="19" extent="16-16"/>
-<wire x1="83.693" y1="44.45" x2="86.106" y2="45.466" width="0" layer="19" extent="1-1"/>
 <wire x1="81.407" y1="50.126" x2="85.201" y2="50.276" width="0" layer="19" extent="1-1"/>
 <wire x1="79.375" y1="50.126" x2="81.407" y2="50.126" width="0" layer="19" extent="1-1"/>
@@
 <wire x1="82.058" y1="57.642" x2="83.439" y2="61.6458" width="0" layer="19" extent="16-16"/>
 <wire x1="74.803" y1="49.022" x2="79.375" y2="50.126" width="0" layer="19" extent="1-1"/>
+<wire x1="86.106" y1="45.466" x2="85.201" y2="50.276" width="0" layer="19" extent="1-1"/>
+<wire x1="83.693" y1="44.45" x2="86.106" y2="45.466" width="0" layer="19" extent="1-1"/>
+<wire x1="89.662" y1="46.676" x2="86.106" y2="45.466" width="0" layer="19" extent="16-16"/>
 <wire x1="86.067" y1="40.132" x2="83.693" y2="44.45" width="0" layer="19" extent="1-1"/>
 <wire x1="85.217" y1="35.263" x2="86.067" y2="40.132" width="0" layer="19" extent="1-1"/>
@@
 <wire x1="4.445" y1="4.445" x2="6.223" y2="20.206" width="0" layer="19" extent="1-1"/>
 <wire x1="4.445" y1="96.012" x2="12.026" y2="68.834" width="0" layer="19" extent="1-1"/>
+<wire x1="-23.683" y1="-33.909" x2="4.445" y2="4.445" width="0" layer="19" extent="1-1"/>
+<wire x1="-21.121" y1="-39.37" x2="-23.683" y2="-33.909" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="SCK_3V">
@@
 <contactref element="C57" pad="1"/>
 <contactref element="U$2" pad="14"/>
-<contactref element="R21" pad="2"/>
 <wire x1="86.106" y1="55.692" x2="83.108" y2="55.692" width="0.4064" layer="16"/>
 <wire x1="83.108" y1="55.692" x2="83.058" y2="55.642" width="0.4064" layer="16"/>
-<wire x1="83.185" y1="50.226" x2="83.185" y2="55.515" width="0.4064" layer="16"/>
 <wire x1="83.185" y1="55.515" x2="83.058" y2="55.642" width="0.4064" layer="16"/>
 <wire x1="76.257" y1="35.4584" x2="76.257" y2="33.217" width="0.254" layer="1"/>
@@
 <wire x1="76.327" y1="33.147" x2="76.327" y2="31.203" width="0.254" layer="16"/>
 <wire x1="76.327" y1="31.203" x2="77.47" y2="30.06" width="0.254" layer="16"/>
-<wire x1="83.185" y1="50.226" x2="82.992" y2="50.226" width="0.254" layer="16"/>
 <wire x1="82.992" y1="50.226" x2="82.042" y2="49.276" width="0.254" layer="16"/>
 <wire x1="82.042" y1="49.276" x2="82.042" y2="44.196" width="0.254" layer="16"/>
@@
 <wire x1="78.359" y1="30.099" x2="77.255" y2="30.099" width="0.254" layer="16"/>
 <wire x1="77.255" y1="30.099" x2="77.47" y2="30.06" width="0.254" layer="16"/>
+<contactref element="IC4" pad="3"/>
+<wire x1="82.992" y1="50.226" x2="83.185" y2="55.515" width="0" layer="19" extent="16-16"/>
+<wire x1="90.932" y1="46.676" x2="82.992" y2="50.226" width="0" layer="19" extent="16-16"/>
 </signal>
 <signal name="ÜBERSPANNUNG">
@@
 <wire x1="90.932" y1="49.149" x2="90.109" y2="48.326" width="0.254" layer="1"/>
 <wire x1="87.249" y1="48.326" x2="90.109" y2="48.326" width="0.254" layer="1"/>
+<contactref element="R3" pad="2"/>
+<wire x1="-21.783" y1="-27.813" x2="79.375" y2="48.426" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="N$9">
@@
 <wire x1="104.7782" y1="20.951" x2="104.39" y2="20.951" width="0.254" layer="16"/>
 </signal>
-<signal name="FB_OV">
-<contactref element="R21" pad="1"/>
-<contactref element="R25" pad="2"/>
-<contactref element="IC4" pad="3"/>
-<wire x1="83.185" y1="48.326" x2="85.217" y2="48.326" width="0.4064" layer="16"/>
-<wire x1="85.217" y1="48.326" x2="85.217" y2="45.085" width="0.254" layer="16"/>
-<wire x1="85.217" y1="45.085" x2="85.725" y2="44.577" width="0.254" layer="16"/>
-<wire x1="85.725" y1="44.577" x2="90.551" y2="44.577" width="0.254" layer="16"/>
-<wire x1="90.551" y1="44.577" x2="90.932" y2="44.958" width="0.254" layer="16"/>
-<wire x1="90.932" y1="44.958" x2="90.932" y2="46.676" width="0.254" layer="16"/>
-</signal>
 <signal name="N$11">
 <contactref element="U$9" pad="15"/>
@@
 <wire x1="77.057" y1="44.0436" x2="77.057" y2="48.294" width="0.4064" layer="1"/>
 <wire x1="77.057" y1="48.294" x2="77.089" y2="48.326" width="0.4064" layer="1"/>
-</signal>
-<signal name="N$34">
-<contactref element="R25" pad="1"/>
-<contactref element="R26" pad="2"/>
-<wire x1="85.217" y1="50.226" x2="87.249" y2="50.226" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$51">
@@
 <signal name="N$3">
 <contactref element="IC4" pad="1"/>
-<contactref element="IC4" pad="2"/>
 <contactref element="R33" pad="1"/>
-<wire x1="92.202" y1="46.676" x2="93.472" y2="46.676" width="0.254" layer="16"/>
 <wire x1="93.472" y1="46.676" x2="93.472" y2="35.118" width="0.254" layer="16"/>
 <wire x1="93.472" y1="35.118" x2="99.634" y2="28.956" width="0.254" layer="16"/>
@@
 <wire x1="119.25" y1="51.054" x2="119.25" y2="48.006" width="0.8128" layer="16"/>
 </signal>
+<signal name="FB_TRIG_LVL">
+<contactref element="R3" pad="1"/>
+<contactref element="R35" pad="2"/>
+<contactref element="IC4" pad="2"/>
+<contactref element="C20" pad="1"/>
+<wire x1="-23.683" y1="-27.813" x2="92.202" y2="46.676" width="0" layer="19" extent="1-16"/>
+<wire x1="-21.783" y1="-33.909" x2="-23.683" y2="-27.813" width="0" layer="19" extent="1-1"/>
+<wire x1="-22.821" y1="-39.37" x2="-21.783" y2="-33.909" width="0" layer="19" extent="1-1"/>
+</signal>
 </signals>

Commit message: kicker 2017 v0.2 final
Parts:
- moved C20 137.6 mm to (83.3, 49.3), flipped to the bottom, turned to 90 degrees
- moved R35 136.4 mm to (85.3, 49.3), flipped to the bottom, turned to 270 degrees
- moved R3 134.5 mm to (87.5, 49.3), flipped to the bottom, turned to 90 degrees
- moved D14 10.0 mm to (94.2, 49.3)
- moved R30 10.0 mm to (97.3, 49.3)
- moved C39 7.11 mm to (88.5, 49.3)
- moved C37 7.11 mm to (86.5, 49.3)
Connections:
- net CAP_+12V renamed CAP_12V
Routing:
- net ADC_CAP: track 32.5 -> 48.1 mm
- net FB_TRIG_LVL: track 0.00 -> 10.4 mm
- net +24V: track 225.4 -> 215.4 mm
- net CAN_H: track 10.7 -> 16.0 mm
- net +5V/3: track 14.7 -> 17.7 mm
- net CAN_L: track 13.7 -> 12.0 mm

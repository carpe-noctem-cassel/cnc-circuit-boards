# Repository carpe-noctem-cassel/cnc-circuit-boards (continued)

## EAGLE design powerSwitch/pcb/CNC-PowerSwitch-2016-v0.96.brd (continued)

Parts:
3V3, 5V, 12V: LEDCHIPLED_0805; CHIPLED_0805
AKKU: LEDCHIPLED_0805; CHIPLED_0805
AKT: LEDCHIPLED_0805; CHIPLED_0805
C1, C7, C8, C24: 100n/10V; C0603
D5: ES1A; SMA-DO214AC
EXT: LEDCHIPLED_0805; CHIPLED_0805
H5, H6, H7, H8: MOUNT-PAD-ROUND3.0; 3,0-PAD
JP1, JP2: PINHD-1X5; 1X05
KICK: LEDCHIPLED_0805; CHIPLED_0805
MOT: LEDCHIPLED_0805; CHIPLED_0805
R1, R4: 560; R0805
R5, R25, R28: 4k7; R0805
R6: 120; M0805
R15, R17, R23: 10k; R0805
R16: 4k7k; R0805
R18, R31: 1k; R0805
RJ_2: RJ10
R_NULL_1, R_NULL_2, R_NULL_3, R_NULL_4: 0; R0402
SJ1: SJ
T1: NX7002BK; SOT23
TDB-05: F/CM12P
U2: TXB0108PWR; SOP65P640X120-20N
U$1: MCP2551-I/SN; SOIC127P600X175-8N

Connections:
12V: R16.1, R_NULL_3.1; also elsewhere on the board
12V-AKKU: R28.1; also elsewhere on the board
12V-EXT: R4.1, R25.1; also elsewhere on the board
+3V3: C7.2, JP2.4, R1.2, U2.2 (VCCA), U2.10 (OE); also elsewhere on the board
+5V: C1.2, C8.2, C24.2, D5.K (C), R18.2, TDB-05.+ (1), U2.19 (VCCB), U$1.3 (VDD); also elsewhere on the board
AKTUATOR: R17.1, R_NULL_2.1; also elsewhere on the board
CANH: R6.1, RJ_2.P$2, U$1.7 (CANH)
CANL: RJ_2.P$3, SJ1.1, U$1.6 (CANL)
CLKOUT_ETH: U2.14 (B6); also elsewhere on the board
CLKOUT_ETH_3V: JP2.1, U2.7 (A6)
CS_ETH: U2.13 (B7); also elsewhere on the board
CS_ETH_3V: JP2.2, U2.8 (A7)
GND: 3V3.C, 5V.C, 12V.C, AKKU.C, AKT.C, C1.1, C7.1, C8.1, C24.1, EXT.C, H5.B3,0, H6.B3,0, H7.B3,0, H8.B3,0, JP2.5, KICK.C, MOT.C, R31.1, RJ_2.P$1, T1.2 (E), U2.11 (GND), U$1.2 (VSS); also elsewhere on the board
INT_ETH: U2.20 (B1); also elsewhere on the board
INT_ETH_3V: JP1.5, U2.1 (A1)
KICKER: R23.1, R_NULL_1.1; also elsewhere on the board
LED_BLAU: R4.2; also elsewhere on the board
LED_GELB: R_NULL_2.2; also elsewhere on the board
LED_GRUEN: R_NULL_4.2; also elsewhere on the board
LED_KICK: R_NULL_1.2
LED_ROT: R_NULL_3.2; also elsewhere on the board
MISO: U2.17 (B3); also elsewhere on the board
MISO_3V: JP1.3, U2.4 (A3)
MOSI: U2.16 (B4); also elsewhere on the board
MOSI_3V: JP1.2, U2.5 (A4)
MOTION: R15.1, R_NULL_4.1; also elsewhere on the board
unnamed: R5.2, T1.1 (B)
unnamed: EXT.A, R25.2
unnamed: KICK.A, R23.2
unnamed: 3V3.A, R1.1
unnamed: R31.2, U$1.8 (RS)
unnamed: R6.2, SJ1.2
unnamed: D5.A, T1.3 (C), TDB-05.- (2)
unnamed: AKKU.A, R28.2
unnamed: 12V.A, R16.2
unnamed: AKT.A, R17.2
unnamed: MOT.A, R15.2
unnamed: 5V.A, R18.1
RST_ETH: U2.12 (B8); also elsewhere on the board
RST_ETH_3V: JP2.3, U2.9 (A8)
RXCAN: U$1.4 (RXD); also elsewhere on the board
SCK: U2.15 (B5); also elsewhere on the board
SCK_3V: JP1.1, U2.6 (A5)
SPEAKER: R5.1; also elsewhere on the board
TXCAN: U$1.1 (TXD); also elsewhere on the board
WOL_ETH: U2.18 (B2); also elsewhere on the board
WOL_ETH_3V: JP1.4, U2.3 (A2)

Notes on the sheet:
CAN
Speaker
Massepads
Leds

Parts:
C6: 100n/10V; C0603
C9: 1000µ/35V; E5-10,5
D1, D2: ES1A; SMA-DO214AC
D4: Z 3.3V; SOT23
IC1: LM1458D; SO08
IC4: BTS555; TO220-51
IC11, IC12: BTS6133; TO252-51
KK1: SK104
Q2, Q3, Q4, Q5: IRF9530; TO220BV
Q6, Q7: BSS84; SOT23-BEC
R7, R26, R34, R42: 10k; R0805
R13, R22: 100k; R0805
R14, R19, R20, R21: 1k; R0805
R24: 560; R0805
R30, R36: 100k 0.1%; R0805
R35, R46: 240k 0.1%; R0805
R37: 560k 0.1%; R0805
R45: 910k 0.1%; R0805
SJ2: SJ
U$3, U$4, U$5, U$6: SK95-2M3
VR1, VR2, VR3, VR7, VR8, VR9: TL431_SOT23; SOT23

Connections:
12V: C9.+, Q3.D, Q5.D; also elsewhere on the board
12V-AKKU: Q4.D, R7.1, R35.2, R42.1; also elsewhere on the board
12V-EXT: Q2.D, R26.1, R34.1, R45.2; also elsewhere on the board
12V-I-OPV: IC1.3 (+IN); also elsewhere on the board
24VIN: IC4.3 (VBB), IC11.TAB (VBB), IC12.TAB (VBB), R37.2; also elsewhere on the board
+5V: C6.1, IC1.8 (V+), R24.1; also elsewhere on the board
ADC3/I-12V: IC1.1 (OUT), R13.2; also elsewhere on the board
ADC5/I-AKT: IC11.IS, R19.2; also elsewhere on the board
ADC6/I-MOT: IC4.4 (IS), R20.2; also elsewhere on the board
ADC8/I-KICK: IC12.IS, R14.2; also elsewhere on the board
AKTUATOR: IC11.OUT1 (OUT), IC11.OUT2 (OUT); also elsewhere on the board
DIV-24V: R36.2, R37.1, VR7.2 (R), VR8.2 (R), VR9.2 (R)
DIV-AKKU: R30.2, R35.1, VR2.1 (C), VR3.2 (R)
DIV-EXT: R45.1, R46.2, VR1.2 (R), VR2.2 (R)
GND: C6.2, C9.-, D4.1 (A), IC1.4 (V-), R14.1, R19.1, R20.1, R21.1, R30.1, R36.1, R46.1, VR1.3 (A), VR2.3 (A), VR3.3 (A); also elsewhere on the board
KICKER: IC12.OUT1 (OUT), IC12.OUT2 (OUT); also elsewhere on the board
MOTION: IC4.1 (OUT1), IC4.5 (OUT2); also elsewhere on the board
unnamed: Q7.C, VR1.1 (C)
unnamed: Q6.C, VR3.1 (C)
unnamed: D2.A, R7.2
unnamed: D1.A, R26.2
unnamed: IC1.2 (-IN), R13.1, R21.2, R22.1
unnamed: D4.3 (C), R22.2, R24.2
unnamed: Q2.S, Q3.S
unnamed: Q4.G, Q5.G, Q6.E, R42.2
unnamed: Q4.S, Q5.S
unnamed: IC12.IN, VR8.1 (C)
unnamed: IC4.2 (IN), VR9.1 (C)
unnamed: IC11.IN, VR7.1 (C)
unnamed: Q2.G, Q3.G, Q7.E, R34.2
SW_12V: D1.K (C), D2.K (C), Q6.B, Q7.B; also elsewhere on the board
SW_AKT: SJ2.1, VR7.3 (A); also elsewhere on the board
SW_KICK: SJ2.2, VR8.3 (A)
SW_MOT: VR9.3 (A); also elsewhere on the board

Notes on the sheet:
Intern
Extern
Supply
Motion
Kicker
Actuator

Board: 2 copper layers, 70.0 x 99.7 mm, 111 parts (52 on the bottom side), 83 nets.

## EAGLE design beagle2can/pcb/beagle2can.brd

Parts:
3V3, 5V, 24V: LEDCHIP-LED0805; CHIP-LED0805
C1, C2: 47uF/35V; PANASONIC_D
C7, C8: 100n; C0603
F1: TE5
H1, H2, H3, H4: MOUNT-PAD-ROUND3.0; 3,0-PAD
IC1: R-785.0-0.5; SIP3
P1: 39-30-04_S; 39-30-?04?
R7: 10k; R0805
R8: 1k; R0805
R9: 560; R0805
U$1: BEAGLEBONE_OUTLINE; BEAGLEBONE_SHIELD

Connections:
+3V3: C7.1, R9.1, U$1.49 (VDD_3V3EXP), U$1.50 (VDD_3V3EXP); also elsewhere on the board
+5V: C2.+, C8.1, IC1.3 (OUT), R8.1, U$1.51 (VDD_5V), U$1.52 (VDD_5V); also elsewhere on the board
+24V: C1.+, F1.2, IC1.1 (IN), R7.1
AIN0: U$1.85 (AIN0)
CAN0_RX: U$1.65 (I2C2_SCL); also elsewhere on the board
CAN0_TX: U$1.66 (I2C2_SDA); also elsewhere on the board
CAN1_RX: U$1.70 (UART1_TXD); also elsewhere on the board
CAN1_TX: U$1.72 (UART1_RXD); also elsewhere on the board
CON_24V: F1.1, P1.3, P1.4; also elsewhere on the board
GND: 3V3.C, 5V.C, 24V.C, C1.-, C2.-, C7.2, C8.2, H1.B3,0, H2.B3,0, H3.B3,0, H4.B3,0, IC1.2 (GND), P1.1, P1.2, U$1.1 (GND), U$1.2 (GND), U$1.47 (GND), U$1.48 (GND), U$1.80 (GNDA_ADC), U$1.89 (GND), U$1.90 (GND), U$1.91 (GND), U$1.92 (GND); also elsewhere on the board
I2C1_SCL: U$1.63 (I2C1_SCL); also elsewhere on the board
I2C1_SDA: U$1.64 (I2C1_SDA); also elsewhere on the board
unnamed: 5V.A, R8.2
unnamed: 24V.A, R7.2
unnamed: 3V3.A, R9.2
SPI1_CLK: U$1.77 (SPI1_SCLK); also elsewhere on the board
SPI1_CS: U$1.74 (SPI1_CS0); also elsewhere on the board
SPI1_DI: U$1.76 (SPI1_DI); also elsewhere on the board
SPI1_DO: U$1.75 (SPI1_DO); also elsewhere on the board
SPI_CS1: U$1.73 (GPIO3_19)
SYS_5V: U$1.53 (SYS_5V)

Parts:
C3, C4, C5, C6: 100n; C0603
R1, R2: 1k; R0805
R3, R4: 120; R0805
R5, R6: 10k; R0805
RJ_1, RJ_2: RJ10
SJ1, SJ2: SJ
SV1: ML10L
U1: TXB0108PWR; SOP65P640X120-20N
U$2, U$3: MCP2551-I/SN; SOIC127P600X175-8N

Connections:
+3V3: C5.1, R5.1, R6.1, SV1.3, U1.2 (VCCA), U1.10 (OE); also elsewhere on the board
+5V: C3.1, C4.1, C6.1, SV1.5, U1.19 (VCCB), U$2.3 (VDD), U$3.3 (VDD); also elsewhere on the board
CAN0_H: R3.1, RJ_1.P$2, U$2.7 (CANH)
CAN0_L: RJ_1.P$3, SJ1.1, U$2.6 (CANL)
CAN0_RS: R1.2, U$2.8 (RS)
CAN0_RX: U1.3 (A2); also elsewhere on the board
CAN0_RX_5V: U1.18 (B2), U$2.4 (RXD)
CAN0_R_TERM: R3.2, SJ1.2
CAN0_TX: U1.1 (A1); also elsewhere on the board
CAN0_TX_5V: U1.20 (B1), U$2.1 (TXD)
CAN1_H: R4.1, RJ_2.P$2, U$3.7 (CANH)
CAN1_L: RJ_2.P$3, SJ2.1, U$3.6 (CANL)
CAN1_RS: R2.2, U$3.8 (RS)
CAN1_RX: U1.5 (A4); also elsewhere on the board
CAN1_RX_5V: U1.16 (B4), U$3.4 (RXD)
CAN1_R_TERM: R4.2, SJ2.2
CAN1_TX: U1.4 (A3); also elsewhere on the board
CAN1_TX_5V: U1.17 (B3), U$3.1 (TXD)
CON_24V: RJ_1.P$4, RJ_2.P$4; also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, R1.1, R2.1, RJ_1.P$1, RJ_2.P$1, SV1.4, SV1.6, U1.11 (GND), U$2.2 (VSS), U$3.2 (VSS); also elsewhere on the board
I2C1_SCL: R5.2, SV1.1; also elsewhere on the board
I2C1_SDA: R6.2, SV1.2; also elsewhere on the board
SPI1_CLK: U1.6 (A5); also elsewhere on the board
SPI1_CLK_5V: SV1.7, U1.15 (B5)
SPI1_CS: U1.9 (A8); also elsewhere on the board
SPI1_CS_5V: SV1.10, U1.12 (B8)
SPI1_DI: U1.8 (A7); also elsewhere on the board
SPI1_DI_5V: SV1.9, U1.13 (B7)
SPI1_DO: U1.7 (A6); also elsewhere on the board
SPI1_DO_5V: SV1.8, U1.14 (B6)

Board: 2 copper layers, 86.6 x 86.5 mm, 36 parts (12 on the bottom side), 34 nets.

## EAGLE design powerSwitch/pcb/CNC-PowerSwitch-2016-v0.92.brd

Parts:
C2, C3: 47µ/35V; PANASONIC_D
C4: 10n/35V; C0603
C5, C14, C16: 100n/10V; C0603
C10, C11: 22p/10V; C0603
D2: ES1A; SMA-DO214AC
F1: FUSETE5; TE5
ISP: ISP; ML10
L2: 68µ; PISM
P1, P4: 39-30-06_S; 39-30-?06?
P6, P8: 39-30-04_S; 39-30-?04?
Q1: 16Mhz; HC49UP
R2, R8, R9: 20k; R0805
R3, R10, R11: 100k; R0805
R12: 0.002; R2512
SJ3: SJ
SV2: SchalterBox; ML10
SV4: extraSchalter; ML10
U1: LM2675M; SOIC127P620X175-8N
U$2: ATMEGA64M1; TQFP32-08

Connections:
12V: F1.1, P1.5; also elsewhere on the board
12V-AKKU: P1.6, R3.1; also elsewhere on the board
12V-EXT: P1.4, R10.1; also elsewhere on the board
12V-I-OPV: P1.2, R12.2; also elsewhere on the board
24VIN: P4.4, P4.5, P4.6, R11.2; also elsewhere on the board
+5V: C3.+, C5.2, C16.1, ISP.2, L2.1, U1.4 (FB), U$2.4 (VCC), U$2.19 (AVCC); also elsewhere on the board
ADC2/I-AKT: U$2.26 (PB5); also elsewhere on the board
ADC3/I-12V: U$2.17 (PC4); also elsewhere on the board
ADC5/I-KICK: U$2.27 (PB6); also elsewhere on the board
ADC6/I-MOT: U$2.13 (PD5); also elsewhere on the board
ADC7/I-EXT: U$2.29 (PD0)
ADC8/12VIN: R2.2, R3.2, U$2.14 (PD6)
ADC9/EXT: R8.2, R10.2, U$2.16 (PB2)
ADC10/24VIN: R9.2, R11.1, U$2.22 (PC6)
AKTUATOR: P6.3; also elsewhere on the board
GND: C2.-, C3.-, C5.1, C10.1, C11.1, C14.1, C16.2, D2.A, ISP.4, ISP.6, ISP.8, ISP.10, P1.1, P1.3, P4.1, P4.2, P4.3, P6.1, P6.2, P8.1, P8.2, R2.1, R8.1, R9.1, R12.1, SV2.1, SV2.2, SV4.1, SV4.2, U1.6 (GND), U$2.5 (GND), U$2.20 (AGND); also elsewhere on the board
ICLED_AKT: U$2.30 (PC0); also elsewhere on the board
ICLED_GRUEN: U$2.28 ((SCK)PB7); also elsewhere on the board
ICLED_KICK: U$2.24 (PB4); also elsewhere on the board
ICLED_ROT: U$2.23 (PB3); also elsewhere on the board
KICKER: P6.4; also elsewhere on the board
LED_1: SV4.7
LED_2: SV4.5
LED_3: SV4.3
LED_BLAU: SV2.9; also elsewhere on the board
LED_GELB: SV2.5; also elsewhere on the board
LED_GRUEN: SV2.7; also elsewhere on the board
LED_KICK: SV4.9; also elsewhere on the board
LED_ROT: SV2.3; also elsewhere on the board
MOTION: P8.3, P8.4; also elsewhere on the board
unnamed: C10.2, Q1.2, U$2.11 (PE2(XTAL2))
unnamed: C11.2, Q1.1, U$2.10 (PE1(XTAL1))
unnamed: C14.2, U$2.21 (AREF)
unnamed: C2.+, F1.2, U1.7 (VIN)
unnamed: C4.2, D2.K (C), L2.2, U1.8 (VSW)
unnamed: C4.1, U1.1 (CB)
RST: ISP.5, U$2.31 (PE0(RESET))
RXCAN: U$2.7 ((RXCAN)PC3); also elsewhere on the board
SPEAKER: U$2.18 (PC5); also elsewhere on the board
SW_1: SV4.8
SW_1/SCK_A: ISP.7, U$2.12 ((RXD)PD4)
SW_2: SV4.6
SW_2/MOSI_A: ISP.1, U$2.2 ((MOSI_A/TXD)PD3)
SW_3: SV4.4
SW_3/MISO_A: ISP.9, U$2.1 ((MISO_A)PD2)
SW_12V: SV2.4, U$2.15 (PD7); also elsewhere on the board
SW_AKT: SJ3.1, SV2.6, U$2.8 (PB0); also elsewhere on the board
SW_BLAU: SV2.10, U$2.3 (PC1)
SW_KICK: SJ3.2, SV4.10, U$2.25 (PC7); also elsewhere on the board
SW_MOT: SV2.8, U$2.9 (PB1); also elsewhere on the board
TXCAN: U$2.6 ((TXCAN)PC2); also elsewhere on the board

Notes on the sheet:
Inputs
ADC
Digital-Supply

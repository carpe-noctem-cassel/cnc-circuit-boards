# Repository carpe-noctem-cassel/cnc-circuit-boards

## EAGLE design kicker/rekick2017/pcb/rekick2017-v0.2.brd

Parts:
C1, C2: 10µ/10V; C0603
C3, C17, C18, C21, C40: 47µ/35V; PANASONIC_D
C19, C23: 10uF/35V; C1206
C59: 100n; C0603
D1, D2: ES1A; SMA-DO214AC
F1: FUSETE5; TE5
H1, H2, H3, H4: MOUNT-PAD-ROUND3.0; 3,0-PAD
IC3: LM1117; SOT223
LED4, LED5, LED6, LED7, LED9, LED10: LEDCHIP-LED0805; CHIP-LED0805
P1: 39-30-06_S; 39-30-?06?
R31: 50k; R0805
R42, R43, R45: 1k; R0805
R44, R49: 4.7k; R0805
R50: 5,6k; R0805
R59: 10k; R0805
U2, U4: R-7805; R-78XX
U3: R-7812; R-78XX
U$4: TMH-D

Connections:
+3V3: C2.1, D2.A, IC3.2 (OUT), IC3.4 (OUT), R42.2; also elsewhere on the board
+5V: C1.1, C18.+, D2.K (C), IC3.3 (IN), R43.2, U2.3 (OUT); also elsewhere on the board
+5V/1: C40.+, R45.2, U4.3 (OUT); also elsewhere on the board
+12V: C21.+, R44.2, U3.3 (OUT); also elsewhere on the board
+24V: C3.+, C17.+, C23.1, D1.K (C), F1.1, R31.1, U2.1 (IN), U3.1 (IN), U4.1 (IN), U$4.1 (U_IN); also elsewhere on the board
ADC_24V_LOGIK/SCK_A: C59.2, R31.2, R50.1; also elsewhere on the board
CAP_0V: C19.2, H2.B3,0, LED9.C, U$4.4 (-U_OUT); also elsewhere on the board
CAP_12V: C19.1, R49.2, U$4.6 (+U_OUT); also elsewhere on the board
CON_24V_BOOSTER: P1.1, P1.2; also elsewhere on the board
CON_24V_LOGIK: F1.2, P1.3, R59.2
GND: C1.2, C2.2, C3.-, C17.-, C18.-, C21.-, C23.2, C40.-, C59.1, D1.A, H1.B3,0, H3.B3,0, H4.B3,0, IC3.1 (GND), LED4.C, LED5.C, LED6.C, LED7.C, LED10.C, P1.6, R50.2, U2.2 (GND), U3.2 (GND), U4.2 (GND), U$4.2 (GND); also elsewhere on the board
GND1: P1.4, P1.5; also elsewhere on the board
unnamed: LED4.A, R42.1
unnamed: LED7.A, R45.1
unnamed: LED5.A, R43.1
unnamed: LED6.A, R44.1
unnamed: LED9.A, R49.1
unnamed: LED10.A, R59.1

Notes on the sheet:
Spannungsversorgung Primärseite
Spannungsversorgung Sekundärseite
Anschluss externe Stromversorgung

Parts:
C4, C5: 22p; C0603
C6, C7, C8: 100n; C0603
D4, D6: ES1A; SMA-DO214AC
Q1: 16MHz; HC49UP
R29, R55: 5,6k; R0805
SV1: ML10
U$2: ATMEGA64M1; TQFP32-08

Connections:
!DONE: U$2.23 (PB3); also elsewhere on the board
!FAULT: U$2.17 (PC4); also elsewhere on the board
+5V: C7.2, C8.2, SV1.2, U$2.4 (VCC), U$2.19 (AVCC); also elsewhere on the board
ACTIVATE_BOOSTER: U$2.18 (PC5); also elsewhere on the board
ACTIVATE_SERVO: U$2.15 (PD7); also elsewhere on the board
ADC_24V_BOOSTER: U$2.13 (PD5); also elsewhere on the board
ADC_24V_LOGIK/SCK_A: SV1.7, U$2.12 ((RXD)PD4); also elsewhere on the board
ADC_CAP: U$2.14 (PD6); also elsewhere on the board
CAN_RX: U$2.7 ((RXCAN)PC3); also elsewhere on the board
CAN_TX: U$2.6 ((TXCAN)PC2); also elsewhere on the board
CHARGE: D6.A; also elsewhere on the board
CS_ETH: U$2.29 (PD0); also elsewhere on the board
GND: C4.1, C5.1, C6.1, C7.1, C8.1, SV1.4, SV1.6, SV1.8, SV1.10, U$2.5 (GND), U$2.20 (AGND); also elsewhere on the board
INT_ETH: U$2.30 (PC0); also elsewhere on the board
KICK: U$2.25 (PC7); also elsewhere on the board
MISO: U$2.8 (PB0); also elsewhere on the board
MOSI: U$2.9 (PB1); also elsewhere on the board
unnamed: R29.1, U$2.27 (PB6)
unnamed: C4.2, Q1.2, U$2.11 (PE2(XTAL2))
unnamed: C5.2, Q1.1, U$2.10 (PE1(XTAL1))
unnamed: C6.2, U$2.21 (AREF)
unnamed: R55.1, U$2.26 (PB5)
unnamed: D6.K (C), U$2.22 (PC6)
unnamed: D4.A, R29.2
NOTAUS: R55.2; also elsewhere on the board
OC0A/MOSI_A: SV1.1, U$2.2 ((MOSI_A/TXD)PD3); also elsewhere on the board
OC1A_FREQ/MISO_A: SV1.9, U$2.1 ((MISO_A)PD2)
RESET_NOTAUS: U$2.24 (PB4); also elsewhere on the board
RST: SV1.5, U$2.31 (PE0(RESET))
RST_ETH: U$2.32 (PD1); also elsewhere on the board
SCK: U$2.28 ((SCK)PB7); also elsewhere on the board
SERVO_PWM: U$2.3 (PC1); also elsewhere on the board
TRIGGER_NOTAUS: D4.K (C); also elsewhere on the board

Notes on the sheet:
Programmierstecker ISP

Parts:
C26, C27, C28: 100n; C0603
JP1, JP2: PINHD-1X5; 1X05
R1: 1k; R0805
R32: 120; R0805
RJ_1: RJ10
SJ1: SJ
U1: TXB0108PWR; SOP65P640X120-20N
U$1: MCP2551-I/SN; SOIC127P600X175-8N

Connections:
+3V3: C27.1, JP2.4, U1.2 (VCCA), U1.10 (OE); also elsewhere on the board
+5V: C26.1, C28.1, U1.19 (VCCB), U$1.3 (VDD); also elsewhere on the board
CAN_H: RJ_1.P$2, SJ1.2, U$1.7 (CANH)
CAN_L: R32.2, RJ_1.P$3, U$1.6 (CANL)
CAN_RX: U$1.4 (RXD); also elsewhere on the board
CAN_TX: U$1.1 (TXD); also elsewhere on the board
CLKOUT_ETH: U1.14 (B6)
CLKOUT_ETH_3V: JP2.1, U1.7 (A6)
CS_ETH: U1.13 (B7); also elsewhere on the board
CS_ETH_3V: JP2.2, U1.8 (A7)
GND: C26.2, C27.2, C28.2, JP2.5, R1.1, RJ_1.P$1, U1.11 (GND), U$1.2 (VSS); also elsewhere on the board
INT_ETH: U1.20 (B1); also elsewhere on the board
INT_ETH_3V: JP1.5, U1.1 (A1)
MISO: U1.17 (B3); also elsewhere on the board
MISO_3V: JP1.3, U1.4 (A3)
MOSI: U1.16 (B4); also elsewhere on the board
MOSI_3V: JP1.2, U1.5 (A4)
unnamed: R1.2, U$1.8 (RS)
unnamed: R32.1, SJ1.1
RST_ETH: U1.12 (B8); also elsewhere on the board
RST_ETH_3V: JP2.3, U1.9 (A8)
SCK: U1.15 (B5); also elsewhere on the board
SCK_3V: JP1.1, U1.6 (A5)
WOL_ETH: U1.18 (B2)
WOL_ETH_3V: JP1.4, U1.3 (A2)

Parts:
C9, C10, C12, C35, C50, C51: 10µ/35V; C1206
C11: 0.1µ/450V; C2220K
C25: 10µ/450V; E5-10,5
C41: 22n; C1206
C52, C55, C56: 100µ/35V; E2,5-7
C58: 100n; C0603
D9: STTH810D; TO220ACS
D13: SMD ZD 12; TO236
KK1: SK104
LED8: LEDCHIP-LED0805; CHIP-LED0805
Q3, Q4: PSMN7R8-120PS; TO220BV
Q5: IPD90P04P4L; D-PAK_TO252AA
R23: 2; N644A
R24, R28: 5,6k; R0805
R27, R34, R64, R65, R200: 50k; R0805
R36, R37, R38, R39: R-EU_R1210; R1210
R46, R69: 10k; R0805
R48, R56: 330k; R0805
R53: 560k; R0805
R54: 150k; R0805
R60: 0; R0805
R61, R67: 80.6k; R0805
R62: 36.5k; R0805
R63, R73: 10m; R2818
R66: 3.6; R2010
T6: NMOSSOT23; SOT-23
U$3: GA3460-BL; GA3459
U$9: LT3751; TSSOP20

Connections:
!DONE: R65.2, U$9.7 (!DONE); also elsewhere on the board
!FAULT: R64.2, U$9.6 (!FAULT); also elsewhere on the board
+5V: R64.1, R65.1; also elsewhere on the board
+12V: C12.2, R54.2, R56.2, U$9.13 (VCC), U$9.14 (LVGATE); also elsewhere on the board
ACTIVATE_BOOSTER: R24.1, R69.2; also elsewhere on the board
ADC_24V_BOOSTER: C58.2, R27.1, R28.2; also elsewhere on the board
CAP_0V: C11.2, C25.-, U$3.7 (S2); also elsewhere on the board
CAP_330V: C11.1, C25.+, D9.C; also elsewhere on the board
CHARGE: R69.1, U$9.8 (CHARGE); also elsewhere on the board
CON_24V_BOOSTER: Q5.3 (S), R23.1, R46.2, R200.2; also elsewhere on the board
FB: U$9.10 (FB); also elsewhere on the board
GND: C12.1, C58.1, R28.1, R60.1, U$9.9 (CLAMP), U$9.21 (GND); also elsewhere on the board
GND1: C9.2, C10.2, C35.2, C50.2, C51.2, C52.-, C55.-, C56.-, LED8.C, R34.1, R63.P$2 (2), R73.P$2 (2), T6.2 (S), U$9.11 (CSN); also elsewhere on the board
unnamed: C9.1, C10.1, C35.1, C41.1, C50.1, C51.1, C52.+, C55.+, C56.+, Q5.4 (D), R23.2, R27.2, R48.2, R53.2, R67.1, U$3.1 (W11), U$3.2 (W21), U$3.3 (W31), U$3.4 (W41)
unnamed: R66.1, U$9.15 (HVGATE)
unnamed: D9.A, U$3.6 (S1)
unnamed: Q3.S, Q4.S, R63.P$1 (1), R73.P$1 (1), U$9.12 (CSP)
unnamed: Q3.G, Q4.G, R66.2
unnamed: R67.2, U$9.1 (R_VTRANS)
unnamed: R60.2, U$9.16 (R_BG)
unnamed: Q3.D, Q4.D, R36.2, R37.2, R38.2, R39.2, R61.1, R62.1, U$3.9 (W12), U$3.10 (W22), U$3.11 (W32), U$3.12 (W42)
unnamed: R61.2, U$9.18 (R_VOUT)
unnamed: R62.2, U$9.20 (R_DCM)
unnamed: R54.1, U$9.4 (UVLO2)
unnamed: R53.1, U$9.3 (OVLO1)
unnamed: D13.C, Q5.1 (G), R200.1
unnamed: D13.A, T6.1 (D)
unnamed: R24.2, R34.2, T6.3 (G)
unnamed: R56.1, U$9.5 (OVLO2)
unnamed: R48.1, U$9.2 (UVLO1)
unnamed: LED8.A, R46.1
unnamed: C41.2, R36.1, R37.1, R38.1, R39.1

Parts:
C31: 10µ/35V; C1206
D5: ES1A; SMA-DO214AC
JP3: PINHD-1X3/90; 1X03/90
JP4: PINHD-1X3; 1X03
KK2: SK104
P2: 39-30-08_S; 39-30-?08?
Q2: IKW40N120T2FKSA1; TO247BV
R7, R8, R19, R47: 5,6k; R0805
R13, R18: 4.7; R0805
R16, R51: 50k; R0805
R17: 390; R0805
R20: ERZE07A621; S10K385
T2: NMOSSOT23; SOT-23
T5: IRLML6344TRPBF; SOT-23
U$6: SI8261ABC; SOIC-8
U$7: DSEI30-12A; TO247AD

Connections:
+5V: R17.2; also elsewhere on the board
+5V/1: JP3.2, JP4.2; also elsewhere on the board
ACTIVATE_SERVO: R47.1; also elsewhere on the board
CAP_0V: C31.2, P2.4, P2.8, Q2.S, R20.1, U$6.5 (GND); also elsewhere on the board
CAP_12V: C31.1, U$6.8 (VDD); also elsewhere on the board
CAP_330V: P2.1, P2.2, P2.5, P2.6, U$7.C; also elsewhere on the board
COIL: P2.3, P2.7, Q2.D, R20.2, U$7.A
GND: JP4.3, R16.1, R51.1, T2.2 (S), T5.2 (S), U$6.1 (NC), U$6.4 (NC); also elsewhere on the board
KICK: R19.1; also elsewhere on the board
unnamed: JP3.1, R7.2
unnamed: JP4.1, R8.2
unnamed: R17.1, U$6.2 (ANODE)
unnamed: D5.K (C), R18.1, U$6.6 (VO), U$6.7 (VO)
unnamed: T2.1 (D), U$6.3 (CATHODE)
unnamed: R19.2, R51.2, T2.3 (G)
unnamed: Q2.G, R13.2, R18.2
unnamed: D5.A, R13.1
unnamed: JP3.3, T5.1 (D)
unnamed: R16.2, R47.2, T5.3 (G)
OC0A/MOSI_A: R8.1; also elsewhere on the board
SERVO_PWM: R7.1; also elsewhere on the board

Parts:
C13, C14, C15, C16: 1µ/16V; C0603
C43, C57: 100n; C0603
C44, C46: 10p; C0603
D8: BZX84-A5V1; TO236
R4: 240k; R0805
R6: 8.2k; R0805
R52: 1k; R0805
R101: 1M, 1%; R1206
U5: ADUM4190BRIZ; SOIC127P1032X265-16N

Connections:
+12V: C13.1, U5.1 (VDD1); also elsewhere on the board
ADC_CAP: C57.1, D8.C, R52.2; also elsewhere on the board
CAP_0V: C14.2, C16.2, C43.2, C44.2, R6.2, U5.9 (GND2), U5.15 (GND2_2); also elsewhere on the board
CAP_12V: C14.1, U5.16 (VDD2); also elsewhere on the board
CAP_330V: R101.2; also elsewhere on the board
GND: C13.2, C15.2, C46.2, C57.2, D8.A, U5.2 (GND1_2), U5.5 (NC), U5.8 (GND1); also elsewhere on the board
unnamed: C43.1, R4.2, R6.1, U5.12 (+IN)
unnamed: R52.1, U5.7 (EAOUT1)
unnamed: R4.1, R101.1
unnamed: U5.10 (COMP), U5.11 (-IN)
unnamed: C15.1, U5.3 (VREG1)
unnamed: C16.1, U5.14 (VREG2)
unnamed: C44.1, U5.13 (REFOUT2)
unnamed: C46.1, U5.4 (REFOUT1)

Parts:
C20, C22, C33, C34, C39, C45, C49: 100n; C0603
C30: 10µ/35V; C1206
C37: 1µ/16V; C0603
D3: SMD ZD 12; TO236
D14: BZX84-A5V1; TO236
IC1: SN74LVC1G02DBVR; SOT23-5
IC2: 4043D; SO16
IC4: MCP602-I/SN; SO08
LED11: rot; CHIP-LED0805
Q6: IRF840; TO220BV
R2, R10: 1M, 1%; R1206
R3: 43k; R0805
R5, R12: 1k; R0805
R11, R70: 50k; R0805
R14: 390; R0805
R15: 5.6k; R0805
R22, R33, R58: 10k; R0805
R30, R57: 3.3k; R0805
R35: 33k; R0805
S1: 10-XX; B3F-10XX
T1: BC859; SOT23-BEC
T4: NMOSSOT23; SOT-23
U$5: SI8261ABC; SOIC-8
U$10, U$11, U$12, U$13, U$14, U$15: RKH214-8R; KH214R-8

Connections:
+5V: C34.1, C45.1, C49.1, IC1.5 (VCC), IC2.16 (VDD), IC4.8 (V+), R12.2, R57.1, R58.2; also elsewhere on the board
+5V/3: C37.1, C39.1, D14.C, R3.2, R30.1
+24V: R30.2; also elsewhere on the board
ADC_CAP: IC4.3 (+IN), IC4.5 (+IN); also elsewhere on the board
CAP_0V: C30.2, D3.A, Q6.S, R11.1, T4.2 (S), U$5.5 (GND); also elsewhere on the board
CAP_12V: C30.1, U$5.8 (VDD); also elsewhere on the board
CAP_330V: R2.1, R10.1, U$10.1, U$12.1, U$14.1; also elsewhere on the board
CHARGE: T1.E; also elsewhere on the board
FB: R33.2; also elsewhere on the board
GND: C20.2, C33.2, C34.2, C37.2, C39.2, C45.2, C49.2, D14.A, IC1.3 (GND), IC2.3 (R0), IC2.4 (S0), IC2.6 (S1), IC2.7 (R1), IC2.8 (VSS), IC4.4 (V-), R22.1, R35.1, T1.C, U$5.1 (NC), U$5.3 (CATHODE), U$5.4 (NC); also elsewhere on the board
unnamed: IC4.1 (OUT), R33.1
unnamed: U$10.2, U$11.2
unnamed: U$12.2, U$13.2
unnamed: Q6.D, U$11.1, U$13.1, U$15.1
unnamed: U$14.2, U$15.2
unnamed: R12.1, S1.3, S1.4 (P1)
unnamed: IC1.1 (I0), IC2.10 (Q2)
unnamed: IC1.2 (I1), IC2.1 (Q3)
unnamed: D3.C, Q6.G, R2.2, R10.2, T4.1 (D)
unnamed: R14.2, U$5.2 (ANODE)
unnamed: R15.1, U$5.6 (VO), U$5.7 (VO)
unnamed: IC2.5 (EN), R58.1
unnamed: R11.2, R15.2, T4.3 (G)
unnamed: LED11.A, R57.2
unnamed: R70.1, T1.B
NOTAUS: IC1.4 (O), LED11.C, R14.1, R70.2; also elsewhere on the board
RESET_NOTAUS: IC2.11 (R2), IC2.15 (R3); also elsewhere on the board
TRIGGER_NOTAUS: C33.1, IC2.14 (S3), R22.2, S1.1 (S), S1.2 (S1); also elsewhere on the board
TRIG_LVL_FB: C20.1, C22.2, IC4.2 (-IN), R5.1, R35.2
TRIG_LVL_OV: C22.1, IC4.6 (-IN), R3.1, R5.2
ÜBERSPANNUNG: IC2.12 (S2), IC4.7 (OUT)

Board: 4 copper layers, 160.0 x 100.0 mm, 184 parts (89 on the bottom side), 119 nets.

## EAGLE design powerSwitch/pcb/CNC-PowerSwitch-2016-v0.96.brd

Parts:
C2, C3, C4: 47µ/35V; PANASONIC_D
C5, C14, C16: 100n/10V; C0603
C10, C11: 22p/10V; C0603
F1: FUSETE5; TE5
IC2: R-78E3.3-0.5; SIP3
IC3: R-78E5.0-0.5; SIP3
ISP: ISP; ML10
P1, P4: 39-30-06_S; 39-30-?06?
P6, P8: 39-30-04_S; 39-30-?04?
Q1: 16Mhz; HC49UP
R2, R8, R9: 20k; R0805
R3, R10, R11: 100k; R0805
R12: 0.002; R2512
SV2: SchalterBox; ML10L
U$2: ATMEGA64M1; TQFP32-08

Connections:
12V: F1.1, P1.5; also elsewhere on the board
12V-AKKU: P1.6, R3.1; also elsewhere on the board
12V-EXT: P1.4, R10.1; also elsewhere on the board
12V-I-OPV: P1.2, R12.2; also elsewhere on the board
24VIN: P4.4, P4.5, P4.6, R11.2; also elsewhere on the board
+3V3: C4.+, IC2.3 (OUT); also elsewhere on the board
+5V: C3.+, C5.2, C16.1, IC3.3 (OUT), ISP.2, U$2.4 (VCC), U$2.19 (AVCC); also elsewhere on the board
ADC1/12V-AKKU/SCK_A: ISP.7, R2.2, R3.2, U$2.12 ((RXD)PD4)
ADC2/12V-EXT: R8.2, R10.2, U$2.13 (PD5)
ADC3/I-12V: U$2.14 (PD6); also elsewhere on the board
ADC5/I-AKT: U$2.16 (PB2); also elsewhere on the board
ADC6/I-MOT: U$2.26 (PB5); also elsewhere on the board
ADC8/I-KICK: U$2.17 (PC4); also elsewhere on the board
ADC9/24V: R9.2, R11.1, U$2.18 (PC5)
AKTUATOR: P6.3; also elsewhere on the board
CLKOUT_ETH: U$2.30 (PC0); also elsewhere on the board
CS_ETH: U$2.32 (PD1); also elsewhere on the board
GND: C2.-, C3.-, C4.-, C5.1, C10.1, C11.1, C14.1, C16.2, IC2.2 (GND), IC3.2 (GND), ISP.4, ISP.6, ISP.8, ISP.10, P1.1, P1.3, P4.1, P4.2, P4.3, P6.1, P6.2, P8.1, P8.2, R2.1, R8.1, R9.1, R12.1, SV2.1, SV2.2, U$2.5 (GND), U$2.20 (AGND); also elsewhere on the board
INT_ETH: U$2.27 (PB6); also elsewhere on the board
KICKER: P6.4; also elsewhere on the board
LED_BLAU: SV2.10; also elsewhere on the board
LED_GELB: SV2.6; also elsewhere on the board
LED_GRUEN: SV2.8; also elsewhere on the board
LED_ROT: SV2.4; also elsewhere on the board
MISO: U$2.8 (PB0); also elsewhere on the board
MISO_A: ISP.9, U$2.1 ((MISO_A)PD2)
MOSI: U$2.9 (PB1); also elsewhere on the board
MOSI_A: ISP.1, U$2.2 ((MOSI_A/TXD)PD3)
MOTION: P8.3, P8.4; also elsewhere on the board
unnamed: C10.2, Q1.2, U$2.11 (PE2(XTAL2))
unnamed: C11.2, Q1.1, U$2.10 (PE1(XTAL1))
unnamed: C14.2, U$2.21 (AREF)
unnamed: C2.+, F1.2, IC2.1 (IN), IC3.1 (IN)
RST: ISP.5, U$2.31 (PE0(RESET))
RST_ETH: U$2.3 (PC1); also elsewhere on the board
RXCAN: U$2.7 ((RXCAN)PC3); also elsewhere on the board
SCK: U$2.28 ((SCK)PB7); also elsewhere on the board
SPEAKER: U$2.25 (PC7); also elsewhere on the board
SW_12V: SV2.3; also elsewhere on the board
SW_AKT: SV2.5, U$2.23 (PB3); also elsewhere on the board
SW_BLAU: SV2.9, U$2.15 (PD7)
SW_MOT: SV2.7, U$2.24 (PB4); also elsewhere on the board
TXCAN: U$2.6 ((TXCAN)PC2); also elsewhere on the board
WOL_ETH: U$2.29 (PD0); also elsewhere on the board

Notes on the sheet:
Inputs
ADC
Digital-Supply

Notices in the files:
parts and their libraries:
r-78xx_10: (c) 2015 Samuel Lourenço
con-molex-mini-fit: Copyright (C) 2011, Bob Starr
recom-intl: Copyright (C) 2010, Bob Starr
